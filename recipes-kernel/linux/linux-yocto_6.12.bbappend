require linux-yocto-amd-zynqmp.inc

KBRANCH:amd-zynqmp  = "v6.12/standard/xlnx-soc"

LINUX_VERSION:amd-zynqmp ?= "6.12.x"
