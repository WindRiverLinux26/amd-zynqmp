require linux-yocto-amd-zynqmp.inc

KBRANCH:amd-zynqmp  = "v6.18/standard/preempt-rt/xlnx-soc"
